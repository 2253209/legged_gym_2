Commit message: 2024-04-26 10:49 将普通脚板URDF修正惯量

File: resources/robots/ZQ_Humanoid/urdf/ZQ_Humanoid.urdf (robot description, URDF)
Before this commit: robot ZQ_Humanoid, 13 links, 12 joints
Links:
- link Y4: mass 2.9408 -> 2.72497
- link Z4: mass 3.15 -> 2.72510
